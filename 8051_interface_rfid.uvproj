# Keil uVision project 8051_interface_rfid.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 8051_interface_rfid +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\at89s52_rfid
  group Source Group 1
    ./: Thu_Vien_LCD_I2C.c Thu_Vien_LCD_I2C.h main.c mfrc522.c mfrc522.h
